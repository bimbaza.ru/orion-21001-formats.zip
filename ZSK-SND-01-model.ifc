Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:46+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SND-01
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Песочница, ZSK-SND-01 Песочница-цветник «Розетка»
In: Площадка
Description: Песочница. Песочница-цветник «Розетка»; Classification: 59.1.15.01-0951 Песочница (Классификатор строительных ресурсов (КСР)); Material: монолитный бетон, 4 отделки на выбор
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SND-01; ModelReference: Песочница-цветник «Розетка»; ProductionYear: 2026; ArticleNumber: ZSK-SND-01
ORION_Изделие - Артикул: ZSK-SND-01; Артикул прежний: SD-SND-01; Наименование: Песочница-цветник «Розетка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 2840×2840×400 мм; Материал: монолитный бетон, 4 отделки на выбор; Цена: 1 200 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/sandboxes/21001; Код КСИ: CPr>EDB180; Класс КСИ: Песочница; Коды КСР: 59.1.15.01-0951 … 59.1.15.01-1014
ADSK - ADSK_Наименование: Песочница-цветник «Розетка»; ADSK_Марка: ZSK-SND-01; ADSK_Код изделия: 59.1.15.01-0951; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: монолитный бетон, 4 отделки на выбор; ADSK_URL страницы изделия: https://зск.рф/catalog/sandboxes/21001
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB180; ZSK_Артикул_прежний: SD-SND-01
Qto_ORION - Длина: 2840 mm; Ширина: 2840 mm; Высота: 400 mm
